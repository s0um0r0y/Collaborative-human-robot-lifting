Commit message: updated intertial tag in URDF

File: urdf/ur5_robotiq_85.urdf (robot description, URDF)
Before this commit: robot ur5_robotiq_85, 20 links, 19 joints
Links:
- link ee_link: mass None -> 0.1879
